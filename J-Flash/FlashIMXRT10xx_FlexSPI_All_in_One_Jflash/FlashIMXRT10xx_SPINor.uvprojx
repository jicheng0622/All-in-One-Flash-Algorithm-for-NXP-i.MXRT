# Keil uVision project FlashIMXRT10xx_SPINor.uvprojx, settings and files
target FlashRT1050_SPINor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: FlashIMXRT1050_SPINor
  AfterMake: cmd.exe /C copy "FlashIMXRT1050_SPINor\%L" ".\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MIMXRT1052CVL5B
  c include: .\Sources;.\devices;.\devices\MIMXRT1050;.\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305  --entry 0x1011
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group drivers
    ./Sources/: hardware_init_MIMXRT.c fsl_flexspi.c fsl_flexspi.h flexspi_nor_flash.c flexspi_nor_flash.h fsl_common.c fsl_common.h clock_config_MIMXRT.c fsl_ocotp.c fsl_ocotp.h
target FlashRT1020_SPINor (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: FlashIMXRT1020_SPINor
  AfterMake: cmd.exe /C copy "FlashIMXRT1020_SPINor\%L" ".\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MIMXRT1021DAG5A
  c include: .\Sources;.\devices;.\devices\MIMXRT1021;.\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305 --entry 0x1011
target FlashRT1060_SPINor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: as above
  output: FlashIMXRT1060_SPINor
  AfterMake: cmd.exe /C copy "FlashIMXRT1060_SPINor\%L" ".\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MIMXRT1062CVL5B
  c include: .\Sources;.\devices;.\devices\MIMXRT1060;.\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305  --entry 0x1011
