<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FlashIMXRT10xx_FlexSPI.ewp</path>
    </project>
    <batchBuild />
</workspace>
