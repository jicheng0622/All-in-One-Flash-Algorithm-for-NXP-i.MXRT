# IAR project FlashIMXRT1050_EVK_FlexSPI.ewp, settings and files
configuration FlashIMXRT1050_EVK_FlexSPI (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1052CVL5B; NDEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; ; Sources; CMSIS\Include; devices; devices\MIMXRT1050
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashIMXRT1050_EVK_FlexSPI.bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: FlashIMXRT1050_OCRAM.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
configuration FlashIMXRT1020_EVK_FlexSPI (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  ICCARM.CCDefines: CPU_MIMXRT1021DAG5A; NDEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; ; Sources; CMSIS\Include; devices; devices\MIMXRT1021
  ILINK.IlinkIcfFile: FlashIMXRT1020_OCRAM.icf
configuration FlashIMXRT1060_FlexSPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MIMXRT1062CVL5B; NDEBUG
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; ; Sources; CMSIS\Include; devices; devices\MIMXRT1060
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: FlashIMXRT1050_RAM512K.icf
  group (top)
    Sources/: clock_config_MIMXRT.c flexspi_nor_flash.c flexspi_nor_flash.h fsl_common.c fsl_flexspi.c fsl_flexspi.h hardware_init_MIMXRT.c
    ./: FlashIMXRT1050_EVK_FlexSPI.c
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
